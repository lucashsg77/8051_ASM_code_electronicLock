# Keil uVision project electronic_lock_8051F388.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F388 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: electronic_lock_8051F388 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: electronic_lock_8051F388.a51
